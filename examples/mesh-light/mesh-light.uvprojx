# Keil uVision project mesh-light.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: mesh-light +hex
  AfterMake: fromelf.exe --bin -o mesh-light.bin ./output/mesh-light.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,BOARD_USE_RGB_LED,BOARD_ID=BOARD_ING9187_02_03_03,PIN_RGB_LED=GIO_GPIO_19
  c include: ..\peripheral_console_freertos\FreeRTOS\include;./src;..\..\src\SigMesh\inc;..\..\src\SigMesh\inc\mesh;..\..\src\SigMesh\inc\mesh_host;../../bundles/noos_exp/inc;../../bundles/noos_exp/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing918;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20001168 size 0xee98
  group APP
    ./src/: main.c profile.c mesh_profile.c mesh_port_stack.c mesh_storage_app.c mesh_storage_low_level.c mesh_port_low_level_init.c hal_flash_bank_eflash.c ble_status.c app_config.h app_debug.h
  group TEST_CODE
    ./src/: BUTTON_TEST.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../bundles/noos_exp/ING9187xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_pinctrl.c peripheral_sysctrl.c peripheral_uart.c peripheral_rtc.c peripheral_gpio.c peripheral_pwm.c
  group Tools
    ../../src/Tools/: trace.c
  group RTOS
    ../peripheral_console_freertos/FreeRTOS/: event_groups.c gen_os_impl.c list.c queue.c tasks.c timers.c
    ../peripheral_console_freertos/FreeRTOS/portable/GCC/ARM_CM3/: port.c
    ../peripheral_console_freertos/FreeRTOS/portable/MemMang/: heap_4.c
  group MeshLib
    ../../src/SigMesh/: SigMesh.lib
software components: CMSIS:CORE 4.3.0
