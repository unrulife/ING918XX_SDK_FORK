# Keil uVision project hid_keyboard.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ing91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(128000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff)
  output: hid_keyboard +hex
  AfterMake: fromelf.exe --bin -o hid_keyboard.bin ./output/hid_keyboard.axf
  c flags: Optim=1 OneElfS=1 v6Lang=4 v6LangP=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,PuTTY,BOARD_USE_KEYS
  c include: ../../bundles/typical/inc;../../bundles/typical/inc/os;../../src/BSP;../../src/FWlib;../../src/StartUP/ing916;../../src/Tools;../../src
  library: MicroLIB
  memory RVCT4: ROM 0x2028000 size 0x58000
  memory RVCT9: RAM 0x20005450 size 0x2bb0
  group APP
    ./src/: main.c profile.c
  group StartUP
    ./src/: startup_ing91600.s
    ../../bundles/typical/ING9168xx/: symdefs.m
  group BSP
    ../../src/BSP/: eflash.c board.c
  group FWlib
    ../../src/FWlib/: peripheral_uart.c peripheral_sysctrl.c peripheral_gpio.c peripheral_pinctrl.c
  group Tools
    ../../src/Tools/: att_db_util.c trace.c btstack_sync.c gatt_client_util.c malloc_override.c
software components: CMSIS:CORE 4.3.0
