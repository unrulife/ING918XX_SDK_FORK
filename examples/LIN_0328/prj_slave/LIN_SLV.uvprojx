# Keil uVision project LIN_SLV.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: LIN_SLV +hex
  AfterMake: fromelf.exe --bin -o LIN_SLV.bin ./output/LIN_SLV.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, CPU_S32K144HFT0VLLT
  c include: .\src;..\lin_stack;..\lin_stack\lin_slave;..\lin_stack\lin_slave\board;..\lin_trans\drivers\inc;..\lin_trans\devices;..\lin_trans\rtos\osif;..\lin_trans\lin\include;..\lin_trans\drivers\src\lpuart;../../../bundles/typical/inc;../../../bundles/typical/inc/os;../../../src/BSP;../../../src/FWlib;../../../src/StartUP/ing918;../../../src/Tools;../../../src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20007478 size 0x8b88
  group APP
    ./src/: main.c profile.c
    ../lin_stack/: lin_phy.c
    ../lin_stack/lin_slave/: lin_stack.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../../bundles/typical/ING9187xx/: symdefs.m
  group BSP
    ../../../src/BSP/: eflash.c
  group FWlib
    ../../../src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_gpio.c
  group Tools
    ../../../src/Tools/: trace.c
  group lin_board
    ../lin_stack/lin_slave/board/: peripherals_LPUART_2.c lin_cfg.c
  group lin_coreapi
    ../lin_trans/lin/coreapi/: lin_j2602_proto.c lin_lin21_proto.c lin_common_proto.c lin_common_api.c
  group lin_lowlevel
    ../lin_trans/lin/lowlevel/: lin.c
  group lin_transport
    ../lin_trans/lin/transport/: lin_commontl_api.c lin_commontl_proto.c
  group lin_driver
    ../lin_trans/drivers/src/: lptmr_driver.c lin_lpuart_driver.c
    ../lin_trans/drivers/src/lin/: lin_driver.c lin_common.c
  group lin_diagnostic
    ../lin_trans/lin/diagnostic/: lin_diagnostic_service.c
software components: CMSIS:CORE 4.3.0
